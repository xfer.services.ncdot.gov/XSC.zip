XSECTION
 
 PROPOSED XS

 /* >>> For english, reset the tolerance to 0.10 <<< */
 Tolerance = 0.10
  
  PATTERN BY STATION
   PATTERN SET
    JOB NUMBER = B61
    BASELINE = L
    HORIZ SCALE = 10
    VERT SCALE = 10
    BEGINNING STATION = 10+50
    ENDING STATION = 15+50
    INC = 50
    LT = 100
    RT = 100
 
  DEFINE "CC01 BERM WIDTH" 10
  DEFINE "CC01 BASE DEPTH" 4
  DEFINE "CS01 CUT SLOPE" 2
  DEFINE "CS01 FILL SLOPE" 2

  /* >>> DEPTH IN INCHES <<< */
  DEFINE "PAVEMENT DEPTH" 11
 
  /* >>> For english, change the extension from .met to .eng <<< */
  include L:\standard.eng
  include L:\cc_defs.eng

 CRITERIA FOR SHAPE CLUSTER
   SHAPE CLUSTER BASELINE = L
   SHAPE CLUSTER PROFILE = LPRO
   SHAPE CLUSTER TIE = 0.0

   SIDE SLOPE LT where (station >=10+50) and (station <=12+00)
     include L:\tmplt01.cri
     include L:\cc01.cri
     include L:\cslp01.cri 
     
   SIDE SLOPE RT where (station >=10+50) and (station <=12+00)
     include L:\tmplt01.cri
     include L:\cc01.cri
     include L:\cslp01.cri 

 SIDE SLOPE LT where (station >=13+50) and (station <=15+50)
     include L:\tmplt01.cri
     include L:\cc01.cri
     include L:\cslp01.cri 
     
   SIDE SLOPE RT where (station >=13+50) and (station <=15+50)
     include L:\tmplt01.cri
     include L:\cc01.cri
     include L:\cslp01.cri 

  SHAPE DGN = B4861_rdy_shp.dgn
   SHAPE SET
    LVNAME = Prop Geopak Pavement Shape Dependent
 
  XS DGN = B4861_L_xsc.dgn
   EXISTING GROUND LINE
    LVNAME= Exist XS Ground Line

  PLOT PARAMETERS
   LINE
    LVNAME= Prop XS Dump Level

     PAVEMENT THICKNESS = 0.0
     DO NOT FILL GAPS BETWEEN CLUSTERS
     WRITE XS INTO DGN= B4861_L_Xsc.dgn
