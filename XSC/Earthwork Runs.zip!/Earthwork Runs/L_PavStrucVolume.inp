XSECTION

  earthwork

  Tolerance = 0.03

     xs dgn = b4861_L_xsc.dgn

        proposed finish grade
            soil type = a2
            fill multiplication factor = 1.00
            type = line
            lvname = Prop XS Finish Grade Earthwork
            lvname = Prop XS Finish Grade
            lvname = Prop XS Subgrade Earthwork
            lvname = Prop XS Finish Grade CurbGutter
            lvname = Prop XS Finish Grade Pavement
            lvname = Prop XS Finish Grade Paved Shoulder
	    lvname = Prop XS Finish Grade Concrete
		co = 0-2

        existing ground line
            soil type = a2
            type = line
            lvname = Exist XS Ground Line

combine common exc + subgrade exc + subsoil exc

  write earthwork shapes
        plot parameters
           lvname = Prop XS Geopak Shape

    stratify shape color

  process earthwork for baseline = L
                     job number = b61
                     beginning station = 10+50
                     ending station = 12+00

  process earthwork for baseline = L
                     job number = b33
                     beginning station = 13+50
                     ending station = 15+50
