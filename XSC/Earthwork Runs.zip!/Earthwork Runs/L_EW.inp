XSECTION

Earthwork
 
tolerance = 0.010000
 
xs dgn = B4861_L_Xsc.dgn

    Proposed Finish Grade
        soil type = suitable
        fill mult factor = 1.000000
            type = line, line_string
            lvname = Prop XS Finish Grade Earthwork
            lvname = Prop XS Subgrade Earthwork
 
    Existing Ground Line
        soil type = suitable
            type = line, line_string
            lvname = Exist XS Ground Line
 
    Write Earthwork Shapes
        plot param
            lvname = Prop XS Earthwork Shape
            Stratify Shape Color
            
/* Brief Report - Next block can be deleted if brief Report is not desired- */            
     combine common exc + subgrade exc + subsoil exc

    End Area Decimal Places = 2
 
    Process Earthwork for Baseline = L
        job number = b61
        beg sta = 10+50
        end sta = 12+00

    Process Earthwork for Baseline = L
        job number = b61
        beg sta = 13+50
        end sta = 15+50

